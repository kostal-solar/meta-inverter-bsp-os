# (C) Copyright 2021
# Lukasz Majewski, DENX Software Engineering, lukma@denx.de.
#

FILESEXTRAPATHS_prepend := "${THISDIR}/${PN}:"
SRC_URI += "file://config_extension.cfg"
